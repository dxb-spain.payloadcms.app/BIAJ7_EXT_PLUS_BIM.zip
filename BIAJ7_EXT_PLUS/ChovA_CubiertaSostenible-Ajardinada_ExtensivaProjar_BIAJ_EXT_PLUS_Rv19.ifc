Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-09T11:51:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - IU alternativa 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 09 11:51:01 2021 * Host: DESKTOP-9PSOHM7 * Database: C:\Users\MODELA~1\AppData\Local\Temp\{8A2D69D6-1EFB-4888-B93D-2975CB3D25B0}\ifc * Database version: 5507 * Database creation date: Tue Mar 09 11:51:00 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 09 11:51:01 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 09 11:51:01 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 24, 0, 5493; RefLongitude: -3, -40, -59, -880065; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm

# IfcRoof (12)
In: Nivel 1
Pset_RoofCommon - Reference: Pieza; IsExternal: no; TotalArea: 16 m2
Name (Pieza:...) | Material
139311 | Tierra
139312 | IM_Polipropileno_Geotextil_VLF150
139313 | IM_PoliestirenoAltoImpacto_Lamina_DiademDiaDrain25H
139314 | IM_Polipropileno_Geotextil_GeofimPP12515
139315 | AT_PoliestirenoExtruidoXPS_Panel_ChovaFoam300M80
139316 | AT_PoliestirenoExtruidoXPS_Panel_ChovaFoam300M60
139317 | IM_Poliester_Geotextil_Geofim150
139318 | IM_LaminaAsfaltica_Lamina_PolitaberGardenCombi50G (LBM 50/G-FP)
139319 | IM_LaminaAsfaltica_Lamina_PolitaberVel30 (LBM 30-FV)
139320 | IM_EmulsionBituminosa_Bote_Supermul
141139 | Formación de pendientes
141825 | Soporte resistente
